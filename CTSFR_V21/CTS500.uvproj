# Keil uVision project CTS500.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2 (CY7C68XXX) Cypress Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0xE000-0xE1FF) CLOCK(48000000) MODDP2
  output: CTS500 +hex
  AfterMake: C:\Cypress\Cypress Suite USB 3.4.7\Firmware\bin\Hex2bix.exe -C 0x04 -I -F 0xc2 -P 0x0082 -V 0x04B4 CTS500.Hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c sub.c dscr.a51 Ezusb.lib INTJmpTb.a51
